require kernel-module-gles.inc

KBUILD_OUTDIR_r8a7795-es2 = "binary_r8a7795_es2_linux_${BUILD}/target_aarch64/kbuild/"
KBUILD_OUTDIR_r8a7795-es3 = "binary_r8a7795_linux_${BUILD}/target_aarch64/kbuild/"
KBUILD_OUTDIR_r8a7796 = "binary_r8a7796_linux_${BUILD}/target_aarch64/kbuild/"
KBUILD_OUTDIR_r8a77965 = "binary_r8a77965_linux_${BUILD}/target_aarch64/kbuild/"

